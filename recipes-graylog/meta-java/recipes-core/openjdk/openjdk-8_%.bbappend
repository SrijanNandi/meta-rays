PACKAGECONFIG_remove += "x11 cups alsa pulseaudio"
